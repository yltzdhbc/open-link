# Keil uVision project proj.uvprojx, settings and files
target gd32f4x5 (6160000::V6.16::ARMCLANG)
  device: GD32F425RG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proj +hex
  AfterMake: C:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin -o  ./app.bin ./Objects/proj.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F425,FIRMWARE_APP
  c include: ..\driver\CMSIS;..\driver\CMSIS\GD\GD32F4xx\Include;..\driver\GD32F4xx_standard_peripheral\Include;..\app;..\bsp;..\..\..\open_protocol;..\..\..\open_protocol\support;..\..\..\open_protocol_port
  memory RVCT4: ROM 0x8020000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c app_protocol.c
    ../../../open_protocol_port/: open_protocol_cmd.c open_protocol_upgrade.c
  group bsp
    ../bsp/: gd32f4xx_it.c systick.c sys_param.c gd32f425_bsp_uart.c gd32f425_bsp_fmc.c gd32f425_bsp_can.c gd32f425_bsp_gpio.c gd32f425_bsp_mcu.c
  group lib
    ../../../open_protocol/: open_protocol.c
    ../../../open_protocol/support/: ringbuffer.c crc.c
  group startup
    ../driver/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../driver/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f405_425.s
  group periph
    ../driver/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
